FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Placeholder for Solo-specific BusyBox config overrides.
