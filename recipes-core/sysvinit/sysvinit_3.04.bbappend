FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Placeholder for Solo-specific inittab or service adjustments.
