FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Placeholder for any Solo-specific dtc patches (unlikely needed).
