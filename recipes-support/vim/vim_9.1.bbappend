FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Placeholder for Solo-specific vim tweaks (unlikely needed).
